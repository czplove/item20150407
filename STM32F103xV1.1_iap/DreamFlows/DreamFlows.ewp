# IAR project DreamFlows.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: ; ..\; library\inc; library\CoreSupport; library\STM32_USB-FS-Device_Driver\inc; user_inc; escore; fatfs
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb.hex
  ILINK.IlinkOutputFile: DreamFlows.out
  ILINK.IlinkIcfFile: stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    library/CoreSupport/: core_cm3.c
    ./: system_stm32f10x.c
  group EWARMv5
    ./: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    library/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group user
    user_main/: bsp.c COMUSE.C eeprom.c fan.c GloblDef.c I2C.c init.c main.c mic.c pm.c printf.C sci0.c sci1.c SimulationSpi.c stm32f10x_it.c voc.c
