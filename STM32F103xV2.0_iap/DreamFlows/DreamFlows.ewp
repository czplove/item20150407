# IAR project DreamFlows.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: VECT_TAB_FLASH; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\; library\inc; library\CoreSupport; user_inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sb.hex
  ILINK.IlinkOutputFile: ext.out
  ILINK.IlinkIcfFile: stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group EWARM
    ./: cortexm3_macro.s stm32f10x_vector.c
  group LIB
    library/src/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group user
    ./: ADUX1020.c adxl345.c bsp.c ClockCalibration.c eeprom.c GloblDef.c hue_light_ctrl.c I2C.c init.c led_display.c main.c printf.C sci0.c stm32f10x_it.c ziku.C
  group user_lib
    ./: COMUSE.a GA.a Library_Calibration.a
