# IAR project IAP.ewp, settings and files
configuration STM3210E-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STM3210E_EVAL; STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\Core\CM3; ..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL; ..\..\..\Utilities\STM32_EVAL
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAP_mb.hex
  ILINK.IlinkOutputFile: IAP.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210E-UP (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STM3210E_EVAL; STM32F10X_HD; USE_STDPERIPH_DRIVER; STM3210E_UP
  OBJCOPY.OOCOutputFile: IAP_sb.hex
  group CMSIS
    ../../../Libraries/CMSIS/Core/CM3/: core_cm3.c
  group Doc
    ../: readme.txt
  group EWARMv5
    ../../../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
  group User
    ../src/: bsp_iap.c common.c iap_hex.c main.c sci0.c stm32f10x_it.c
