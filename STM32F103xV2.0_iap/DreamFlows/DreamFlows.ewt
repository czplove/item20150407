<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>EWARM</name>
    <file>
      <name>$PROJ_DIR$\cortexm3_macro.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm32f10x_vector.c</name>
    </file>
  </group>
  <group>
    <name>LIB</name>
    <file>
      <name>$PROJ_DIR$\library\src\stm32f10x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\src\stm32f10x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\src\stm32f10x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\src\stm32f10x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\src\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\src\stm32f10x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\src\stm32f10x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\src\stm32f10x_lib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\src\stm32f10x_nvic.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\src\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\src\stm32f10x_systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\src\stm32f10x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\src\stm32f10x_usart.c</name>
    </file>
  </group>
  <group>
    <name>user</name>
    <file>
      <name>$PROJ_DIR$\ADUX1020.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\adxl345.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ClockCalibration.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\eeprom.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\GloblDef.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hue_light_ctrl.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\I2C.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\led_display.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\printf.C</name>
    </file>
    <file>
      <name>$PROJ_DIR$\sci0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm32f10x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ziku.C</name>
    </file>
  </group>
  <group>
    <name>user_lib</name>
    <file>
      <name>$PROJ_DIR$\COMUSE.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\GA.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Library_Calibration.a</name>
    </file>
  </group>
</project>


